# IAR project MSP430_NODE.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.newCCIncludePaths: ../src
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group src
    src/: i2c.c ir_lora.c ir_lora.h key.c led.c led.h main.c msp430x54xA_adc12_02.c msp430x54xA_uart_0.c msp430x54xA_uart_1.c msp430x54xA_uart_2.c msp430x54xA_uart_3.c power_clk.c power_clk.h protocol.c protocol.h timer.c uart.h utils.c
